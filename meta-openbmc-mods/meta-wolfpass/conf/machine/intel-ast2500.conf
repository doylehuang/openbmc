## meta-openbmc-mods/meta-wolfpass/conf/machine/intel-ast2500.conf
```bitbake
FLASH_SIZE = "32768"
require conf/machine/include/intel-ast2500.inc
FLASH_SIZE = "32768"
```
