SRC_URI = "git://github.com/Intel-BMC/phosphor-webui;protocol=ssh;branch=intel2"
SRCREV = "0ecbfca6ecffe61da127d2c0b61ec26e4414d6ec"
#SRCREV = "68c48ed0e48f57bf3092bc5a5bd4b8ac336a4d93"
